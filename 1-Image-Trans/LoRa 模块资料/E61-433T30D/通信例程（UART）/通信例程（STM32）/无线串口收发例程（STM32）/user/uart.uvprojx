# Keil uVision project uart.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: uart
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\user;..\stm32f0;..\lib\inc;..\lib\src;..\drive
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user
    ./: main.c
  group lib
    ../lib/src/: stm32f0xx_usart.c stm32f0xx_rcc.c stm32f0xx_gpio.c
  group drive
    ../drive/: uart.c key.c led.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
